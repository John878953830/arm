# Keil uVision project SCA_Controller.uvprojx, settings and files
target SCA_Controller (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SCA_Controller +hex
  c flags: Optim=1 uC99=1
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\SYSTEM;..\BSP;..\SCA
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group BSP
    ../BSP/: bsp.c bsp_can.c
  group SCA
    ../SCA/: SCA_APP.c SCA_API.c SCA_Protocol.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c timer.c
  group CORE
    ../CORE/: startup_stm32f429_439xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_crc.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, CMSIS:NN Lib 1.2.0
